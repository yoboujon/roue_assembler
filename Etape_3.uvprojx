# Keil uVision project Etape_3.uvprojx, settings and files
target Simulé (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Simu_Etape0
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F10X_MD
  c include: ..\pilotes\Include
  asm define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: Principale.asm FonctionEtape.asm FonctionEtape2.asm FonctionEtape3.asm Mire.asm
  group Pilote
    ./: Matos.lib
target Réel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Reel_Etape0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL
  c include: ..\pilotes\Include
  asm define: STM32F10X_CL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
